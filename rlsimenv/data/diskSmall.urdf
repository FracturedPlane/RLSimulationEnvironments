Commit message: Working on new planning env

File: rlsimenv/data/diskSmall.urdf (robot description, URDF)
Before this commit: robot disk.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision cylinder length=0.05 radius=1.0; visual cylinder length=0.05 radius=1.0
