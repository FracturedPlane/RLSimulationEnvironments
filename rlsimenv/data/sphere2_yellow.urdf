Commit message: yellow!

File: rlsimenv/data/sphere2_yellow.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 1.1 -> 10.0; geometry collision sphere radius=0.5; visual mesh filename=sphere_smooth.obj scale=0.5 0.5 0.5
